
RDEPENDS_${PN} += "\
    agl-service-nfc \
"

