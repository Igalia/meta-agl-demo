RDEPENDS_${PN} += " \
	packagegroup-agl-ivi-identity \
"
