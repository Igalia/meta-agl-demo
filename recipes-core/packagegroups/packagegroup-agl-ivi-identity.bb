inherit packagegroup

RDEPENDS_${PN} += "\
    agl-service-data-persistence \
    agl-service-identity-agent \
"

LICENSE = "MIT"

