RDEPENDS_${PN} += "\
    audiomanager \
    virtual/pulseaudio-config \
    "
