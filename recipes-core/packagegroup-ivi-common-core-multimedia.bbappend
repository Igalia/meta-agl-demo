RDEPENDS_${PN} += "\
    audiomanager \
    "
	