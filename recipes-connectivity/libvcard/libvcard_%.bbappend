SRCREV = "9b43ca01865f171cdd8a7d47b6da7c1a41c03e38"

ALLOW_EMPTY_${PN} = "1"
