FILESEXTRAPATHS_prepend := "${THISDIR}/pulseaudio-8.0:"

SRC_URI += " \
     file://0006-auto-load-module-router.patch \
"

