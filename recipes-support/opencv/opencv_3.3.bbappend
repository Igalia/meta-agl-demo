PACKAGECONFIG ?= "jpeg png v4l libv4l gstreamer"
